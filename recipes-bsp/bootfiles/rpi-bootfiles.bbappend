RPIFW_DATE = "20230405"
SRC_URI[sha256sum] = "89fa175753264c8199bc7b1cc7e8dad033a8c7dfc57a6014cc59cb77a5c7abc6"

DEPENDS += " rpi-autoboot "
