CMDLINE_ROOTFS="root=/dev/mmcblk0p5 ${CMDLINE_ROOT_FSTYPE} rootwait"
