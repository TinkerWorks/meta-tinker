inherit bundle

require name.inc
require ../common/bundle.inc

RAUC_SLOT_rootfs ?= "controlcenter-image"
RAUC_SLOT_bootfs ?= "controlcenter-image"
